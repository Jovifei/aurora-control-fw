# Keil uVision project AuroraControl.uvprojx, settings and files
target AuroraControl (6160000::V6.16::ARMCLANG)
  device: G32F031K8 Geehy
  pack: Geehy.G32F031_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0xFC00) CPUTYPE("Cortex-M0+") CLOCK(64000000) ELITTLE
  output: AuroraControl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_FULL_DDL_DRIVER,G32F031xx
  c misc: -std=c11 -Wall -Wextra -Werror
  c include: ..\..\app;..\..\service;..\..\driver;..\..\board;..\..\vendor\cmsis\Include;..\..\vendor\device\Include;..\..\vendor\ddl\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xFC00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../../app/: app.c charger.c measurement.c mppt.c power_stage.c protection.c protocol.c storage.c ui.c
  group Service
    ../../service/: service.c
  group Driver
    ../../driver/: drv_adc.c drv_comp.c drv_flash.c drv_io.c drv_pwm.c drv_system.c drv_uart.c drv_watchdog.c
  group Board
    ../../board/: board.c
  group Vendor
    ../../vendor/device/Source/: startup_g32f031.s system_g32f031.c
    ../../vendor/ddl/Source/: g32f031_ddl_adc.c g32f031_ddl_atmr.c g32f031_ddl_comp0.c g32f031_ddl_comp1.c g32f031_ddl_dma.c g32f031_ddl_flash.c g32f031_ddl_gpio.c g32f031_ddl_opa.c g32f031_ddl_rcc.c g32f031_ddl_usart.c g32f031_ddl_utils.c
  group Project
    ./: main.c interrupts.c AuroraControl.sct
